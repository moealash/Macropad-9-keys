# Repository moealash/Macropad-9-keys

File README.md:

# 9 Key Macropad

## Project Overview
This is a 9 key macropad that I designed using KiCad.  
A macropad is like a small keyboard that can run shortcuts or macros when you press a button.

My macropad has a 3×3 layout (9 buttons total). When you press a key it sends a command to the computer.

## Features
9 mechanical keys
Custom PCB made in KiCad
Small 3×3 layout
Can run macros or shortcuts
Connects to a computer with USB

## Hardware
Parts used in this project:

XIAO RP2040 microcontroller
9 Cherry MX switches
9 keycaps
Diodes
Custom PCB

## How It Works
Each key is connected to a pin on the microcontroller.  
When a key is pressed, the microcontroller detects it and sends a keyboard signal to the computer.

## Future Improvements
Things I might add later:
RGB lights
A rotary knob
Better PCB layout
 A 3D printed case

## Author
Mohammad Alashwal

## KiCad design macropad project/macropad.kicad_pcb

Board: 2 copper layers, 10 parts (0 on the bottom side), 10 nets.

Parts:
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: MOUDLE-SEEEDUINO-XIAO; XIAO-RP2040-DIP

Connections:
GND: SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, U1.13 (GND)
unnamed: SW2.1, U1.10 (PA5_A9_D9_MISO)
unnamed: SW1.1, U1.11 (PA6_A10_D10_MOSI)
unnamed: SW3.1, U1.9 (PA7_A8_D8_SCK)
unnamed: SW7.1, U1.5 (PA8_A4_D4_SDA)
unnamed: SW6.1, U1.6 (PA9_A5_D5_SCL)
unnamed: SW9.1, U1.3 (PA10_A2_D2)
unnamed: SW8.1, U1.4 (PA11_A3_D3)
unnamed: SW5.1, U1.7 (PB08_A6_D6_TX)
unnamed: SW4.1, U1.8 (PB09_A7_D7_RX)

## Commit log

2026-03-01 This is all the stuff for the macro pad
2026-03-06 README.md
2026-03-07 Wiring Fix
    I forgot to to gnd wire to the gnd
